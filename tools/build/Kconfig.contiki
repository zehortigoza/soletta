## tools/build/Kconfig.contiki
```kconfig
config CONTIKI
    def_bool y
    select FEATURE_HW_GPIO
    select FEATURE_HW_UART
    select FEATURE_FLOW
```
